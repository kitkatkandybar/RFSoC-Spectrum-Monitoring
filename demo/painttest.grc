options:
  parameters:
    generate_options: qt_gui
    id: grpainttest
    output_language: python
    title: Test GR Paint
  states: {}

blocks:
- name: fc
  id: variable
  parameters:
    value: int(88.9e6)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(1e5)
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /Users/swoboj/Documents/Python/GNURadio/grcfiles/marcy.bin
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '0.'
    bandwidth: '20000000'
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: fc
    samplerate: samp_rate
    type: fc32
  states: {}
- name: paint_paint_bc_0
  id: paint_paint_bc
  parameters:
    equalization: EQUALIZATION_OFF
    randomsrc: INTERNAL
    repeats: '4'
    width: '1920'
  states: {}

connections:
- [blocks_file_source_0, '0', paint_paint_bc_0, '0']
- [blocks_throttle_0, '0', iio_pluto_sink_0, '0']
- [paint_paint_bc_0, '0', blocks_throttle_0, '0']

metadata:
  file_format: 1
